# Keil uVision project Project.uvprojx, settings and files
target GD32F10X_HD (6160000::V6.16::ARMCLANG)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\Firmware\CMSIS;..\;..\..\Firmware\GD32F10x_standard_peripheral\Include;..\Drv;..\..\Utilities\Third_Party\cherry_usb;..\..\Utilities\Third_Party\cherry_usb\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: gd32f10x_it.c main.c
  group Drv
    ../Drv/: uart.c systick.c
  group CherryUSB
    ../../Utilities/Third_Party/cherry_usb/: usbd_core.c usb_dc_fsdev.c
    ../../Utilities/Third_Party/cherry_usb/cdc/: usbd_cdc.c usbh_cdc_acm.c
  group Peripherals
    ../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s startup_gd32f10x_hd.s startup_gd32f10x_md.s startup_gd32f10x_xd.s
  group Utilities
    ../../Utilities/: gd32f10x_eval.c
  group Doc
    ../: readme.txt
